# Keil uVision project lpc55s3x_mdk.uvprojx, settings and files
target lpc55s3x_mdk (6160000::V6.16::.\ARMCompiler6.16)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: lpc55s3x_mdk.out
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S36JBD100, MCUXPRESSO_SDK
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: drivers;source
  asm define: CPU_LPC55S36JBD100, DEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\LPC55S36_flash.scf
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
    ./drivers/: startup_LPC55S36.S system_LPC55S36.c system_LPC55S36.h
  group source
    ./source/: main.c app_led.c app_led.h app_printf.c app_printf.h clock_config.c clock_config.h
